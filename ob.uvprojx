# Keil uVision project ob.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: XMC4300-F100x256 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IRAM(0x20000000,0x0FFC0) IRAM2(0x1FFF0000,0x10000) IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ob
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./src/: ob.cpp
software components: Board Support:Buttons 1.0.1, Board Support:LED 1.0.1, Device:XMClib:GPIO 2.1.24, Device:XMClib:SPI 2.1.24, Device:XMClib:UART 2.1.24
